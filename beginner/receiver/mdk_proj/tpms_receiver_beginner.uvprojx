# Keil uVision project tpms_receiver_beginner.uvprojx, settings and files
target tpms_receiver_beginner (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tpms_receiver_beginner +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\src\CMSIS\CM3\CoreSupport;..\src\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src\inc;..\src\STM32F10x_StdPeriph_Driver\inc;..\src\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../src/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../src/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../src/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group driver
    ../src/driver/: clock.c CRC.c delay.c iic1.c led.c mysprintf.c spi.c sys.c tim.c usart.c
  group user
    ../src/user/: display.c main.c oled.c SP37Data.c TDA5235.c
