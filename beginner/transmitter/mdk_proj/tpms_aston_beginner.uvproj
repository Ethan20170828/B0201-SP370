# Keil uVision project tpms_aston_beginner.uvproj, settings and files
target tpms_aston_beginner (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: tpms_aston_beginner +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\inc
  group startup
    ../src/startup/: STARTUP.A51
  group lib
    ../src/lib/: SP37_ROMLibrary.LIB
  group user
    ../src/user/: main.c RF.c SP37.c uart.c
